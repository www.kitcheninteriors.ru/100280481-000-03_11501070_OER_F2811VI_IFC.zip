Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-09-27T07:54:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 27 07:54:20 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f57a219a-39b8-4211-8802-fb00b3a5f5b4\3cba865c-f9e2-4466-92ff-27d61785bdec\ifc * Database version: 5507 * Database creation date: Tue Sep 27 07:54:19 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 27 07:54:20 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 27 07:54:20 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11501070_OER_F2811VI:37281101_OER_11501070_F2811VI, (2)
In: Default
Type - Material: z_Miele_Design_GRGR
Type - Pset_BuildingElementProxyCommon - Reference: 37281101_OER_11501070_F2811VI
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Freezers / freezers
Type - Pset_QuantityTakeOff - Reference: 37281101_OER_11501070_F2811VI
Type - Pset_ProvisionForVoid - Width: 756 mm; Height: 2127 mm; Depth: 610 mm
Material: z_Miele_Design_GRGR, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_IN, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_358006
Description: Flow; FlowDirection: SOURCEANDSINK
